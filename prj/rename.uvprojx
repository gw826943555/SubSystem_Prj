# Keil uVision project rename.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test1 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c misc: --cpp
  c include: ..\CMSIS\CM3\CoreSupport;..\Libraries\inc;..\USER;..\HARDWARE\inc;..\StCan2;..\ADC;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\DHT11
  memory RVCT4: ROM 0x8008000 size 0x8000
  memory RVCT5: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c CommonConfig.c CCan.cpp CPWM.c IO.c Timer.cpp iap_cmd.cpp rwIO.cpp globaldata.cpp
  group DHT11
    ../DHT11/: delay.c dht11.c sys.c
  group StCan2
    ../StCan2/: bsp_led.c bsp_usrconfig.c ColorArray.cpp bsp_TimBase.c
  group ADC
    ../ADC/: ADC.c
  group CMSIS
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
  group Liberaries
    ../Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c
  group startup
    ../Libraries/startup/: startup_stm32f10x_hd.s
  group doc
    ./: canLoadBin.py
